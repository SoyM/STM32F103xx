# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\ADC;..\HARDWARE\CONTROL;..\HARDWARE\DataScope_DP;..\HARDWARE\DHT11;..\HARDWARE\DMP;..\HARDWARE\ENCODER;..\HARDWARE\EXTI;..\HARDWARE\filter;..\HARDWARE\IIC;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\MOTOR;..\HARDWARE\MPU6050;..\HARDWARE\show;..\HARDWARE\STMFLASH;..\HARDWARE\TIMER;..\HARDWARE\USART2;..\HARDWARE\HC_SR04;..\HARDWARE\OLED;..\HARDWARE\TCS3200;..\HARDWARE\RFID
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: startup_stm32f10x_hd.s
  group USER
    ./: test.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: LED.C
    ../HARDWARE/IIC/: IOI2C.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/MPU6050/: MPU6050.c
    ../HARDWARE/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/CONTROL/: control.c
    ../HARDWARE/filter/: filter.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/show/: show.c
    ../HARDWARE/DataScope_DP/: DataScope_DP.C
    ../HARDWARE/DHT11/: DHT11.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/HC_SR04/: HC_SR04.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/TCS3200/: tcs3200.c
    ../HARDWARE/RFID/: rc522.c
